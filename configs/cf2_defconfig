## configs/cf2_defconfig
```kconfig
CONFIG_PLATFORM_CF2=y

//CONFIG_DECK_FORCE="scd30Deck"
//CONFIG_DECK_FORCE="mics5524Deck"
```
